# Keil uVision project ficus_application.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ficus_application
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx
  c include: ..\CMSIS\Device\ST\STM32F4xx\Include;..\CMSIS\Include;..\USER\I2C;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20005000 size 0x15000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../USER/: main.c stm32fxxx_it.c HMC5883L.c
  group VTLIB
    ../VTLIB/: ficus_f4_dll.lib
  group CIMIS
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: system_stm32f4xx.c startup_stm32f4xx.s
software components: CMSIS:CORE 5.2.0
